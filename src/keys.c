// ============================================================================
// 文件：src/keys.c
// 用途：按键消抖、单键与双键检测。
//
// 读取七个实体按键，每次扫描比较新旧状态，连续三次相同才确认变化。
// scan_keys() 按“采样消抖 → 双键优先 → 单键松开”的顺序完成一次处理。
// SW4 确认按下时开始/暂停；其余键先登记待办，松开后执行，组成双键则取消待办。
// 双键分别为 SW3+SW8 复位计时、SW5+SW9 交换比分、SW6+SW7 清零比分。
// 主循环通常每 10 毫秒调用一次 scan_keys()；本模块调用 countdown.c 和 score.c。
// ============================================================================

#include "keys.h"
#include "countdown.h"
#include "score.h"

// 编号：0=SW3，1=SW4，2=SW8，3=SW5，4=SW6，5=SW7，6=SW9。
// 先消抖，再判双键，最后处理单键松开；数组仅在本文件使用。
static unsigned char key_last[7] = {0};                                         // 7 个元素分别保存 7 个键上一次的原始状态；{0} 让全部元素初始化为 0。
static unsigned char key_count[7] = {0};                                        // 给每个键单独计数，记录连续多少次读到相同状态，避免一个键的抖动影响其他键。
static unsigned char key_stable[7] = {0};                                       // 保存消抖后的确认状态：1 是按住，0 是松开；程序用它判断双键。
static unsigned char key_pending[7] = {0};                                      // 保存待执行的单键动作：1 表示松开后执行；识别为双键时清成 0。
static unsigned char chord_latched[3] = {0};                                    // 三组组合键各有一个锁：触发后置 1，防止按住时反复复位或交换。

// 函数用途：detect_key_events() —— 读取七个按键，消抖并生成松开事件。
// 工作说明：连续三次采样相同才确认变化；SW4 按下立即切换计时，其余键登记单键待办，返回本轮刚松开的按键位图。
static unsigned char detect_key_events(void)                                    // 采样七个按键，消抖后返回刚松开的键的位图。
{                                                                               // 开始这一段语句块；配对的右花括号表示这段结束。
    // masks[i] 是第 i 个按键在端口上对应的那一位。最后一个 SW9 接 P1。
    static const unsigned char __code masks[7] = {                              // 按键位掩码表，与七个键的统一编号一一对应，存放在程序存储器。
        KEY_MINUS, KEY_TOGGLE, KEY_PLUS,                                        // 下标 0、1、2 分别对应 SW3、SW4、SW8。
        KEY_A_MINUS, KEY_B_PLUS, KEY_B_MINUS, KEY_A_PLUS                        // 下标 3、4、5、6 分别对应 SW5、SW6、SW7、SW9。
    };                                                                          // 结束数组初始化；分号表示这条数组定义完成。
    // i 是键编号，down 是本次原始状态；released 位图初始为 0，表示暂无松开事件。
    unsigned char i, down, released = 0;                                        // 第 i 位为 1：按键 i 刚松开

    for (i = 0; i < 7; ++i) {                                                   // i 从 0 开始，每轮加 1，逐一处理七个键，处理完下标 6 后退出。
        // “按下接地”意味着读到 0 才是按下。SW9 从 P1 读，其余从 P3 读。
        down = (i == 6) ? ((P1 & masks[i]) == 0)                                // 第 6 号键 SW9 接 P1；按掩码取出对应位，读到 0 就令 down=1。
                         : ((P3 & masks[i]) == 0);                              // 其他六个键从 P3 读取；同样把低电平转换成“按下=1”。
        // 连续采样相同就增加计数；一旦变化，就从第 1 次重新计数。
        if (down == key_last[i]) {                                              // 本次原始状态与上次一样，说明连续稳定次数可以增加。
            if (key_count[i] < 3) ++key_count[i];                               // 次数不足 3 就加 1；达到 3 后保持，避免一直加到溢出。
        } else {                                                                // 上一条件不成立时进入此分支：按所在层级处理状态变化或非 SW4 按键。
            key_last[i] = down;                                                 // 原始状态变了，先记住这个新状态，供下次采样比较。
            key_count[i] = 1;                                                   // 新状态刚出现一次，从 1 重新累计，而不是沿用旧状态的次数。
        }                                                                       // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
        /* 每 10ms 采样一次，三次采样从第一次到第三次相隔 20ms。
         * 满 3 次且不同于已确认状态，才产生一次按下／松开事件。 */
        if (key_count[i] >= 3 && down != key_stable[i]) {                       // 连续读到三次相同状态且不同于原确认状态，才认定真正发生按下或松开。
            key_stable[i] = down;                                               // 更新消抖后的状态，双键判断随后就能读取它。
            if (down) {                                                         // 新确认的状态为 1，表示刚刚按下；为 0 则表示刚刚松开。
                if (i == 1) {                                                   // 编号 1 是 SW4，开始/暂停需要在确认按下时立即处理。
                    toggle_timer();                                             // 调用开始/暂停函数，切换倒计时运行状态。
                } else {                                                        // 上一条件不成立时进入此分支：按所在层级处理状态变化或非 SW4 按键。
                    // 暂存单键动作，等松开再执行；若组成双键会清掉它。
                    key_pending[i] = 1;                                         // 其他键先只登记待办动作，不马上加减，留出识别双键的机会。
                }                                                               // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
            } else released |= (unsigned char)(1 << i);                         // 若刚松开，把位图中第 i 位置 1，例如 i=2 时置 0x04；其他位保持。
        }                                                                       // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    }                                                                           // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    return released;                                                            // 将本轮七个键的松开事件位图返回给调用者。
}                                                                               // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。

// 函数用途：handle_key_chords() —— 识别并执行三组双键操作。
// 工作说明：两键同时确认按住时，取消对应单键待办并执行一次复位或交换；利用锁定标记避免长按反复触发。
static void handle_key_chords(void)                                             // 识别并处理三组双键组合。
{                                                                               // 开始这一段语句块；配对的右花括号表示这段结束。
    /* 必须在检查“单键松开”之前调用本函数。
     * 两个键先后按下也可以识别：各自消抖后只要同时处于按下状态即可。
     * 清掉 pending 标志，松开时就不会再附带执行单键加减。 */
    // 双键 1：SW3+SW8 复位计时。
    if (key_stable[0] && key_stable[2]) {                                       // SW3 与 SW8 消抖后都处于按下状态，构成计时复位双键。
        key_pending[0] = 0;                                                     // 取消 SW3 待执行的减一分钟，避免松开组合键时又减时间。
        key_pending[2] = 0;                                                     // 取消 SW8 待执行的加一分钟。
        if (!chord_latched[0]) {                                                // 第 0 组双键尚未触发过时才执行；按住期间不会重复复位。
            reset_timer();                                                      // 将倒计时恢复到设定时间，并暂停。
            chord_latched[0] = 1;                                               // 锁住本次双键动作，直到两个键都松开才解锁。
        }                                                                       // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    }                                                                           // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    if (!key_stable[0] && !key_stable[2]) chord_latched[0] = 0;                 // SW3 和 SW8 都确认松开后解锁，允许下次再复位。

    // 双键 2：SW5+SW9 交换 A、B 分数，不执行 A 队单键加减。
    if (key_stable[3] && key_stable[6]) {                                       // SW5 与 SW9 都按下，构成交换两队比分的双键。
        key_pending[3] = 0;                                                     // 取消 SW5 对应的 A 队单键减分。
        key_pending[6] = 0;                                                     // 取消 SW9 对应的 A 队单键加分。
        if (!chord_latched[1]) {                                                // 第 1 组双键本次还没有触发时才允许交换。
            swap_scores();                                                      // 调用交换函数，把 A、B 两队分数互换。
            chord_latched[1] = 1;                                               // 标记这次交换已执行，避免按住时不停来回交换。
        }                                                                       // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    }                                                                           // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    if (!key_stable[3] && !key_stable[6]) chord_latched[1] = 0;                 // SW5 和 SW9 全部松开后才允许下一次交换。

    // 双键 3：SW6+SW7 清零两队分数，不执行 B 队单键加减。
    if (key_stable[4] && key_stable[5]) {                                       // SW6 与 SW7 都按下，构成计分复位双键。
        key_pending[4] = 0;                                                     // 取消 SW6 的 B 队单键加分。
        key_pending[5] = 0;                                                     // 取消 SW7 的 B 队单键减分。
        if (!chord_latched[2]) {                                                // 第 2 组双键尚未触发过时才执行清零。
            reset_scores();                                                     // 调用比分清零函数，让 A、B 都变为 00。
            chord_latched[2] = 1;                                               // 锁住本次比分清零动作，长按不反复处理。
        }                                                                       // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    }                                                                           // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    if (!key_stable[4] && !key_stable[5]) chord_latched[2] = 0;                 // SW6 和 SW7 全部松开后解锁这组双键。
}                                                                               // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。

// 函数用途：handle_single_key_releases() —— 执行没有被双键取消的单键动作。
// 工作说明：参数 released 表示本轮哪些键刚松开；只有松开事件与待办标记同时存在才加减时间或分数，最后清除待办。
static void handle_single_key_releases(unsigned char released)                  // 接收松开位图 released，执行未被组合键取消的单键动作。
{                                                                               // 开始这一段语句块；配对的右花括号表示这段结束。
    unsigned char i;                                                            // 声明循环下标 i，用来逐个访问数组元素。
    // released 的位号与前述按键编号一致：例如 0x01 是按键 0（SW3）。
    if (released & 0x01) {                                                      // 用 & 检查松开位图的第 0 位，即 SW3 是否在这一轮刚松开。
        if (key_pending[0]) change_minute(0);                                   // SW3 仍有待办单键动作时才减一分钟；0 表示减法。
    }                                                                           // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    if (released & 0x04) {                                                      // 检查第 2 位，即 SW8 是否在这一轮刚松开。
        if (key_pending[2]) change_minute(1);                                   // SW8 未被组合键取消时加一分钟；1 表示加法。
    }                                                                           // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。
    if ((released & 0x08) && key_pending[3]) change_score(0, 0);                // SW5 刚松开且仍待执行：第一个 0 选 A 队，第二个 0 表示减分。
    if ((released & 0x10) && key_pending[4]) change_score(1, 1);                // SW6 刚松开且仍待执行：B 队加 1 分。
    if ((released & 0x20) && key_pending[5]) change_score(1, 0);                // SW7 刚松开且仍待执行：B 队减 1 分。
    if ((released & 0x40) && key_pending[6]) change_score(0, 1);                // SW9 刚松开且仍待执行：A 队加 1 分。
    // 一次按下—松开只执行一次，最后清掉这次的待执行标记。
    for (i = 0; i < 7; ++i)                                                     // 依次检查七个键；没有花括号时循环只控制紧接着的一条语句。
        if (released & (1 << i)) key_pending[i] = 0;                            // 1 左移 i 位得到对应键的掩码；凡是这轮松开的键，都清除待办标记。
}                                                                               // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。

// 函数用途：scan_keys() —— 组织一次完整的按键处理。
// 工作说明：依次调用采样消抖、双键判断、单键松开处理，确保双键优先；通常由主循环每 10 毫秒调用一次。
void scan_keys(void)                                                            // 按采样、双键、单键顺序完成一次按键处理。
{                                                                               // 开始这一段语句块；配对的右花括号表示这段结束。
    /* detect 只负责把机械按键变成稳定事件；chords 先取得优先权；
     * 最后 releases 才执行没有组成双键的单键动作。 */
    unsigned char released = detect_key_events();                               // 先采样和消抖，接收返回的松开事件位图。
    handle_key_chords();                                                        // 优先处理双键，并取消相关的单键待办标记。
    handle_single_key_releases(released);                                       // 再处理刚松开的单键，所以组成双键的键不会额外加减。
}                                                                               // 结束这一层语句块，按外层循环、判断或函数的结构继续执行。

